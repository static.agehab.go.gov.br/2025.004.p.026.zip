Properties of the parts of a building model (IFC4)

# File
Description: IFC4
Time: 2023-08-15T16:50:12
Made in: IfcPlusPlus

# IfcBuildingStorey (2)
Name | LongName | Elevation (cm)
TERREO | TERREO | 0
COBERTURA | COBERTURA | 265

# IfcFlowMeter: Hidrômetros
In: TERREO
Type - PredefinedType: WATERMETER
AltoQi_Builder - Indicação: HIDRÔMETRO; Posição: Direta
Identificação_Elemento - Aplicação: Hidrômetro principal; Descrição: Hidrômetros; Nome: Cavalete 3/4" - Conjunto completo; Classe: PVC rígido soldável; Tipo: Hidrômetros; Rede: Alimentação
Pset_FlowMeterTypeCommon - Reference: Hidrômetros
AltoQi_QiBuilder-Itens_Associados - Hidrômetro - Cavalete 3/4" - Cavalete para Hidrômetro 3/4": 1

# IfcInterceptor: Caixas de Gordura
In: TERREO
Type - PredefinedType: OIL
AltoQi_Builder - Comprimento: 30 cm; Largura: 30 cm; Indicação: CG PVC- 30x30 cm; Posição: Direta
Identificação_Elemento - Aplicação: Caixa de passagem; Descrição: Caixas de Gordura; Nome: CG PVC- 30x30 cm; Classe: Caixas de Passagem; Tipo: Caixas de Gordura; Rede: Esgoto (Gordura)
Pset_InterceptorTypeCommon - Reference: Caixas de Gordura
AltoQi_QiBuilder-Itens_Associados - Caixas de Passagem - Caixa de gordura PVC - CG 30 cm: 1

# IfcPipeFitting: Bucha de redução sold. curta (7)
In: TERREO
Type - PredefinedType: TRANSITION
AltoQi_Builder - Indicação: 32 mm - 25 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Bucha de redução sold. curta; Nome: 32 mm - 25 mm; Classe: PVC rígido soldável; Tipo: Bucha de redução sold. curta; Rede: Água fria
Pset_PipeFittingTypeCommon - Reference: Bucha de redução sold. curta
AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. curta - 32 mm - 25 mm: 1
Name
AF-1
AF-2
AF-3
AF-4
AF-5
AF-6
AF-7

# IfcPipeFitting: Curva 45 Longa para Esgoto Sanitário
In: TERREO
Type - PredefinedType: BEND
AltoQi_Builder - Indicação: 50mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Curva 45 Longa para Esgoto Sanitário; Nome: 50mm; Classe: PVC Esgoto; Tipo: Curva 45 Longa para Esgoto Sanitário; Rede: Esgoto (Gordura)
Pset_PipeFittingTypeCommon - Reference: Curva 45 Longa para Esgoto Sanitário
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Curva 45 longa - 50 mm: 1

# IfcPipeFitting: Curva 90 curta- coluna (3)
In: TERREO
Type - PredefinedType: BEND
AltoQi_Builder - Indicação: 50 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Curva 90 curta- coluna; Nome: 50 mm; Classe: PVC Esgoto; Tipo: Curva 90 curta- coluna; Rede: Ventilação
Pset_PipeFittingTypeCommon - Reference: Curva 90 curta- coluna
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Curva 90 curta - 50 mm: 1
Name
CV-1
CV-2
CV-3

# IfcPipeFitting: Joelho 45 (6)
In: TERREO
Type - PredefinedType: BEND
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Joelho 45; Classe: PVC Esgoto; Tipo: Joelho 45; Rede: Esgoto
Pset_PipeFittingTypeCommon - Reference: Joelho 45
Name | Indicação = Nome
3 x  | 40 mm | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 45 - 40 mm: 1
3 x  | 50 mm | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 45 - 50 mm: 1

# IfcPipeFitting: Joelho 90 soldável (24)
Type - PredefinedType: BEND
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Joelho 90 soldável; Classe: PVC rígido soldável; Tipo: Joelho 90 soldável
Pset_PipeFittingTypeCommon - Reference: Joelho 90 soldável
Name | In | Indicação = Nome | Rede
3 x  | TERREO | 25 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 25 mm: 1
2 x  | TERREO | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 25 mm: 1
AL-1 | TERREO | 25 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 25 mm: 1
5 x  | COBERTURA | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 32 mm: 1
3 x  | COBERTURA | 25 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 25 mm: 1
2 x  | COBERTURA | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 25 mm: 1
AF-1 | COBERTURA | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 32 mm: 1
AF-2 | COBERTURA | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 32 mm: 1
AF-3 | COBERTURA | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 32 mm: 1
AF-4 | COBERTURA | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 32 mm: 1
AF-5 | COBERTURA | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 32 mm: 1
AF-6 | COBERTURA | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 32 mm: 1
AF-7 | COBERTURA | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 32 mm: 1
AL-1 | COBERTURA | 25 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 25 mm: 1

# IfcPipeFitting: Junção simples (2)
In: TERREO
Type - PredefinedType: JUNCTION
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Junção simples; Classe: PVC Esgoto; Tipo: Junção simples; Rede: Esgoto
Pset_PipeFittingTypeCommon - Reference: Junção simples
Name | Indicação = Nome
 | 40 mm x 40 mm | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 40 mm x 40 mm: 1
 | 100 mm - 50 mm | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 100 mm - 50 mm: 1

# IfcPipeFitting: Ramais de Ventilação (4)
In: TERREO
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Ramal de ventilação; Classe: PVC Esgoto; Tipo: Ramais de Ventilação
Pset_PipeFittingTypeCommon - Reference: Ramais de Ventilação
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 90 - 50 mm: 1
Name | Indicação = Nome | Descrição | Rede | PVC Esgoto - Tê sanitário - 50 mm - 50 mm
 | 100mm - 50mm-90° | Ramais de ventilação | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tê sanitário - 100 mm - 50 mm: 1
2 x  | 50mm-50mm-135º | Ramais de Ventilação | Ventilação | 1
 | 50mm-50mm-90º | Ramais de Ventilação | Ventilação | 1

# IfcPipeFitting: Te 90 soldável (7)
Type - PredefinedType: JUNCTION
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Te 90 soldável; Classe: PVC rígido soldável; Tipo: Te 90 soldável
Pset_PipeFittingTypeCommon - Reference: Te 90 soldável
Name | In | Indicação = Nome | Rede | PVC rígido soldável - Tê 90 soldável - 32 mm
 | TERREO | 25 mm | Alimentação | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê 90 soldável - 25 mm: 1
 | TERREO | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê 90 soldável - 25 mm: 1
5 x  | COBERTURA | 32 mm | Água fria | 1

# IfcPipeFitting: Te 90 soldável (centro)
In: COBERTURA
Type - PredefinedType: JUNCTION
AltoQi_Builder - Indicação: 32 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Te 90 soldável; Nome: 32 mm; Classe: PVC rígido soldável; Tipo: Te 90 soldável (centro); Rede: Água fria
Pset_PipeFittingTypeCommon - Reference: Te 90 soldável (centro)
AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê 90 soldável - 32 mm: 1

# IfcPipeFitting: Te 90 soldável c/ redução lateral
In: COBERTURA
Type - PredefinedType: JUNCTION
AltoQi_Builder - Indicação: 32 mm- 25mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Te 90 soldável c/ redução lateral; Nome: 32 mm- 25mm; Classe: PVC rígido soldável; Tipo: Te 90 soldável c/ redução lateral; Rede: Água fria
Pset_PipeFittingTypeCommon - Reference: Te 90 soldável c/ redução lateral
AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. curta - 32 mm - 25 mm: 1; PVC rígido soldável - Tê 90 soldável - 32 mm: 1

# IfcPipeFitting: Te sanitário
In: TERREO
Type - PredefinedType: JUNCTION
AltoQi_Builder - Indicação: 50 mm -50 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Te sanitário; Nome: 50 mm -50 mm; Classe: PVC Esgoto; Tipo: Te sanitário; Rede: Ventilação
Pset_PipeFittingTypeCommon - Reference: Te sanitário
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tê sanitário - 50 mm - 50 mm: 1

# IfcPipeSegment: Tubo rígido c/ ponta lisa com luva simples (7)
In: TERREO
Type - PredefinedType: RIGIDSEGMENT
AltoQi_Builder - Comprimento máximo: 599.8 cm; Diâmetro interno: 4 cm; Diâmetro: ø1 1/2"; Espessura: 0.12 cm; Indicação: 40 mm; Inclinação: 2
Identificação_Elemento - Nome: 40 mm; Classe: PVC Esgoto; Tipo: Tubo rígido c/ ponta lisa com luva simples; Rede: Esgoto; Aplicação: Circular
Pset_PipeSegmentTypeCommon - Reference: Tubo rígido c/ ponta lisa com luva simples; InnerDiameter: 4 cm; NominalDiameter: ø1 1/2"
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva - 40 mm: 1
Name | Comprimento (cm) | PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm (cm)
 | 72.06 | 72.0566
 | 5.87 | 5.87078
 | 87.51 | 87.5088
 | 9.87 | 9.86768
 | 38.38 | 38.3822
 | 5 | 5.0022
 | 19.24 | 19.241

# IfcPipeSegment: Tubo rígido c/ ponta lisa e luva simples (25)
Type - PredefinedType: RIGIDSEGMENT
Identificação_Elemento - Classe: PVC Esgoto; Tipo: Tubo rígido c/ ponta lisa e luva simples; Aplicação: Circular
Pset_PipeSegmentTypeCommon - Reference: Tubo rígido c/ ponta lisa e luva simples
Name | In | Comprimento máximo (cm) | Diâmetro interno (cm) = InnerDiameter (cm) | Diâmetro = NominalDiameter | Espessura (cm) | Indicação | Inclinação | Comprimento (cm) | Nome | Rede | PVC Esgoto - Luva simples - 50 mm | PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2" (cm)
 | TERREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 2 | 11.76 | 50 mm - 2" | Esgoto | 1 | 11.7563
 | TERREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 21 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 21.0012 cm
 | TERREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 1 | 31.09 | 50 mm - 2" | Ventilação | 1 | 31.0947
 | TERREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 2 | 188.48 | 50 mm - 2" | Esgoto | 1 | 188.482
 | TERREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 2 | 189.66 | 50 mm - 2" | Esgoto | 1 | 189.662
 | TERREO | 296.1 | 7.5 | ø3" | 0.17 | 75 mm | 2 | 73.34 | 75 mm - 3" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 73.3375 cm
 | TERREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 2 | 44.2 | 50 mm - 2" | Esgoto (Gordura) | 1 | 44.2023
 | TERREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 2 | 382.9 | 50 mm - 2" | Esgoto (Gordura) | 1 | 382.905
 | TERREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 2 | 11.7 | 50 mm - 2" | Esgoto | 1 | 11.7029
 | TERREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 2 | 5.43 | 50 mm - 2" | Esgoto | 1 | 5.43483
 | TERREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 46.6 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 46.6022 cm
 | TERREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 2 | 9.88 | 50 mm - 2" | Esgoto | 1 | 9.87876
 | TERREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 684.42 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 684.42 cm
 | TERREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 452.03 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 452.033 cm
 | TERREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 2 | 19.28 | 50 mm - 2" | Esgoto | 1 | 19.2785
 | TERREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 1 | 28.03 | 50 mm - 2" | Ventilação | 1 | 28.0322
 | TERREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 2 | 24.21 | 50 mm - 2" | Esgoto | 1 | 24.2069
 | TERREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 1 | 3 | 50 mm - 2" | Ventilação | 1 | 3.00076
 | TERREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 1 | 12.67 | 50 mm - 2" | Ventilação | 1 | 12.6737
 | TERREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 2 | 62.65 | 50 mm - 2" | Esgoto (Gordura) | 1 | 62.6513
 | TERREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 1 | 30.41 | 50 mm - 2" | Ventilação | 1 | 30.4101
 | TERREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 131.06 | 100 mm - 4" | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 131.064 cm
 | COBERTURA | 296.5 | 5 | ø2" | 0.16 | 50 mm | 1 | 436.01 | 50 mm - 2" | Ventilação | 1 | 436.008
 | COBERTURA | 296.5 | 5 | ø2" | 0.16 | 50 mm | 1 | 436.6 | 50 mm - 2" | Ventilação | 1 | 436.598
 | COBERTURA | 296.5 | 5 | ø2" | 0.16 | 50 mm | 2 | 599.54 | 50 mm - 2" | Ventilação | 1 | 599.541

# IfcPipeSegment: Tubos - diâmetro interno comercial (64)
Type - PredefinedType: RIGIDSEGMENT
AltoQi_Builder - Comprimento máximo: 300 cm
Identificação_Elemento - Classe: PVC rígido soldável; Tipo: Tubos - diâmetro interno comercial; Aplicação: Circular
Pset_PipeSegmentTypeCommon - Reference: Tubos - diâmetro interno comercial
Name | In | Diâmetro interno (cm) = InnerDiameter (cm) | Diâmetro = NominalDiameter | Espessura (cm) | Indicação = Nome | Comprimento (cm) | Rede | PVC rígido soldável - Tubos - 25 mm (cm)
 | TERREO | 2.16 | ø3/4" | 0.17 | 25 mm | 3.93 | Alimentação | 3.92766
 | TERREO | 2.16 | ø3/4" | 0.17 | 25 mm | 14.76 | Alimentação | 14.7567
 | TERREO | 2.16 | ø3/4" | 0.17 | 25 mm | 528.83 | Alimentação | 528.826
 | TERREO | 2.16 | ø3/4" | 0.17 | 25 mm | 78.5 | Água fria | 78.5
 | TERREO | 2.16 | ø3/4" | 0.17 | 25 mm | 24.11 | Alimentação | 24.109
 | TERREO | 2.16 | ø3/4" | 0.17 | 25 mm | 6.65 | Água fria | 6.65
7 x  | TERREO | 2.16 | ø3/4" | 0.17 | 25 mm | 37.5 | Água fria | 37.5
 | TERREO | 2.16 | ø3/4" | 0.17 | 25 mm | 147.5 | Água fria | 147.5
 | TERREO | 2.16 | ø3/4" | 0.17 | 25 mm | 96.25 | Água fria | 96.25
2 x  | TERREO | 2.16 | ø3/4" | 0.17 | 25 mm | 146.25 | Água fria | 146.25
 | TERREO | 2.16 | ø3/4" | 0.17 | 25 mm | 181 | Água fria | 181
 | TERREO | 2.16 | ø3/4" | 0.17 | 25 mm | 47.25 | Água fria | 47.25
 | TERREO | 2.16 | ø3/4" | 0.17 | 25 mm | 96 | Água fria | 96
 | TERREO | 2.16 | ø3/4" | 0.17 | 25 mm | 5.8 | Água fria | 5.8
 | TERREO | 2.16 | ø3/4" | 0.17 | 25 mm | 14.4 | Água fria | 14.4
 | TERREO | 2.16 | ø3/4" | 0.17 | 25 mm | 96.5 | Água fria | 96.5
 | TERREO | 2.16 | ø3/4" | 0.17 | 25 mm | 115.4 | Água fria | 115.4
 | TERREO | 2.16 | ø3/4" | 0.17 | 25 mm | 35.8 | Alimentação | 35.8
 | TERREO | 2.16 | ø3/4" | 0.17 | 25 mm | 8.5 | Água fria | 8.5
 | COBERTURA | 2.78 | ø1" | 0.21 | 32 mm | 4.38 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 4.38018 cm
 | COBERTURA | 2.78 | ø1" | 0.21 | 32 mm | 3.8 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 3.8 cm
 | COBERTURA | 2.78 | ø1" | 0.21 | 32 mm | 85.7 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 85.7 cm
 | COBERTURA | 2.16 | ø3/4" | 0.17 | 25 mm | 79.2 | Água fria | 79.2016
 | COBERTURA | 2.16 | ø3/4" | 0.17 | 25 mm | 7.13 | Água fria | 7.13129
 | COBERTURA | 2.16 | ø3/4" | 0.17 | 25 mm | 7.9 | Água fria | 7.9
 | COBERTURA | 2.78 | ø1" | 0.21 | 32 mm | 21.79 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 21.795 cm
 | COBERTURA | 2.78 | ø1" | 0.21 | 32 mm | 85.6 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 85.6 cm
6 x  | COBERTURA | 2.78 | ø1" | 0.21 | 32 mm | 17.8 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 17.8 cm
 | COBERTURA | 2.78 | ø1" | 0.21 | 32 mm | 61.7 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 61.7001 cm
 | COBERTURA | 2.78 | ø1" | 0.21 | 32 mm | 29.7 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 29.7002 cm
 | COBERTURA | 2.78 | ø1" | 0.21 | 32 mm | 35.8 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 35.8 cm
 | COBERTURA | 2.78 | ø1" | 0.21 | 32 mm | 30.7 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 30.7002 cm
 | COBERTURA | 2.78 | ø1" | 0.21 | 32 mm | 246.8 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 246.8 cm
 | COBERTURA | 2.78 | ø1" | 0.21 | 32 mm | 30.7 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 30.6999 cm
 | COBERTURA | 2.78 | ø1" | 0.21 | 32 mm | 415.53 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 415.532 cm
 | COBERTURA | 2.78 | ø1" | 0.21 | 32 mm | 23.68 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 23.6768 cm
 | COBERTURA | 2.78 | ø1" | 0.21 | 32 mm | 48.2 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 48.2 cm
 | COBERTURA | 2.16 | ø3/4" | 0.17 | 25 mm | 285.8 | Alimentação | 285.8
 | COBERTURA | 2.78 | ø1" | 0.21 | 32 mm | 18.02 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 18.0237 cm
 | COBERTURA | 2.16 | ø3/4" | 0.17 | 25 mm | 64.55 | Alimentação | 64.55
2 x  | COBERTURA | 2.78 | ø1" | 0.21 | 32 mm | 28.2 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 28.2 cm
 | COBERTURA | 2.78 | ø1" | 0.21 | 32 mm | 103.8 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 103.8 cm
 | COBERTURA | 2.16 | ø3/4" | 0.17 | 25 mm | 79.55 | Alimentação | 79.55
 | COBERTURA | 2.78 | ø1" | 0.21 | 32 mm | 69.7 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 69.7 cm
 | COBERTURA | 2.78 | ø1" | 0.21 | 32 mm | 60.7 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 60.7 cm
 | COBERTURA | 2.78 | ø1" | 0.21 | 32 mm | 64.66 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 64.6634 cm
 | COBERTURA | 2.78 | ø1" | 0.21 | 32 mm | 28.1 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 28.1 cm
 | COBERTURA | 2.16 | ø3/4" | 0.17 | 25 mm | 456.81 | Alimentação | 456.81
 | COBERTURA | 2.78 | ø1" | 0.21 | 32 mm | 27.9 | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 27.9 cm
 | COBERTURA | 2.16 | ø3/4" | 0.17 | 25 mm | 394.86 | Alimentação | 394.856
 | COBERTURA | 2.16 | ø3/4" | 0.17 | 25 mm | 9.27 | Alimentação | 9.26673

# IfcSanitaryTerminal: Bebedouro com Te de 90º
In: TERREO
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Vazão de projeto (l/s): 0.1; Indicação: BE; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Bebedouro com Te de 90º; Nome: 25 mm - 1/2"; Classe: PVC rígido soldável; Tipo: Bebedouro com Te de 90º; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Bebedouro com Te de 90º
AltoQi_QiBuilder-Itens_Associados - Aparelho - Bebedouro - 25mmx 1/2": 1; PVC Acessórios - Engate flexível plástico - 1/2 - 30cm: 1; PVC soldável azul c/ bucha latão - Tê red.90 sold c/ bucha latão B central - 25 mm -1/2": 1

# IfcSanitaryTerminal: Chuveiro
In: TERREO
Type - PredefinedType: SHOWER
AltoQi_Builder - Vazão de projeto (l/s): 0.1; Indicação: CH; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Chuveiro; Nome: 25mm x 3/4"; Classe: PVC rígido soldável; Tipo: Chuveiro; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Chuveiro
AltoQi_QiBuilder-Itens_Associados - Aparelho - Chuveiro - 25mm x 3/4": 1; PVC soldável azul c/ bucha latão - Joelho 90º soldável com bucha de latão - 25 mm - 3/4": 1

# IfcSanitaryTerminal: Chuveiro Residencial
In: TERREO
Type - PredefinedType: SHOWER
AltoQi_Builder - Indicação: 40mm; Posição: Direta
Identificação_Elemento - Aplicação: Aparelho sanitário; Descrição: Chuveiro Residencial; Nome: 40mm; Classe: PVC Esgoto; Tipo: Chuveiro Residencial; Rede: Esgoto
Pset_SanitaryTerminalTypeCommon - Reference: Chuveiro Residencial
AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Ralo sifonado alt. reg. saída 40 - 100 mm - 40 mm: 1; PVC Esgoto - Curva 90 curta - 40 mm: 1

# IfcSanitaryTerminal: Ducha Higiênica com Joelho de 90º
In: TERREO
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Vazão de projeto (l/s): 0.2; Indicação: DH; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Ducha Higiênica; Nome: 25 mm x 1/2"; Classe: PVC rígido soldável; Tipo: Ducha Higiênica com Joelho de 90º; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Ducha Higiênica com Joelho de 90º
AltoQi_QiBuilder-Itens_Associados - Aparelho - Ducha higiênica - 25mm x 1/2": 1; PVC soldável azul c/ bucha latão - Joelho de redução 90º soldável com bucha de latão - 25 mm- 1/2": 1

# IfcSanitaryTerminal: Lavatório Residencial com sifão
In: TERREO
Type - PredefinedType: WASHHANDBASIN
AltoQi_Builder - Indicação: 40mm; Posição: Direta
Identificação_Elemento - Aplicação: Aparelho sanitário; Descrição: Lavatório Residencial com sifão; Nome: 40mm; Classe: PVC Esgoto; Tipo: Lavatório Residencial com sifão; Rede: Esgoto
Pset_SanitaryTerminalTypeCommon - Reference: Lavatório Residencial com sifão
AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Sifão flexível c/ Adaptador - 1.1/2" - 1.1/2": 1; PVC Acessórios - Válvula p/ lavatório e tanque - 1": 1; PVC Esgoto - Curva 90 curta - 40 mm: 1; PVC Esgoto - Joelho 90 c/anel p/ esgoto secundário - 40 mm - 1.1/2": 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 60 cm

# IfcSanitaryTerminal: Lavatório com joelho de 90º
In: TERREO
Type - PredefinedType: WASHHANDBASIN
AltoQi_Builder - Vazão de projeto (l/s): 0.15; Indicação: LV; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Lavatório com joelho de 90º; Nome: 25 mm - 1/2"; Classe: PVC rígido soldável; Tipo: Lavatório com joelho de 90º; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Lavatório com joelho de 90º
AltoQi_QiBuilder-Itens_Associados - Aparelho - Torneira de lavatório - 25 mm - 1/2": 1; PVC Acessórios - Engate flexível plástico - 1/2 - 30cm: 1; PVC soldável azul c/ bucha latão - Joelho de redução 90º soldável com bucha de latão - 25 mm- 1/2": 1

# IfcSanitaryTerminal: Máquina de Lavar Roupas DN 50mm
In: TERREO
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Indicação: 50mm; Posição: Direta
Identificação_Elemento - Aplicação: Aparelho sanitário; Descrição: Máquina de Lavar Roupas DN 50mm; Nome: 50mm; Classe: PVC Esgoto; Tipo: Máquina de Lavar Roupas DN 50mm; Rede: Esgoto
Pset_SanitaryTerminalTypeCommon - Reference: Máquina de Lavar Roupas DN 50mm
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 90 - 50 mm: 2; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 90 cm

# IfcSanitaryTerminal: Máquina de lavar roupa com joelho de 90º
In: TERREO
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Vazão de projeto (l/s): 0.3; Indicação: MLR; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Máquina de lavar roupa com joelho de 90º; Nome: 25 mm - 3/4"; Classe: PVC rígido soldável; Tipo: Máquina de lavar roupa com joelho de 90º; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Máquina de lavar roupa com joelho de 90º
AltoQi_QiBuilder-Itens_Associados - Aparelho - Máquina de Lavar Roupa - 25mm x 3/4": 1; PVC soldável azul c/ bucha latão - Joelho 90º soldável com bucha de latão - 25 mm - 3/4": 1

# IfcSanitaryTerminal: Pia de Cozinha Residencial com Sifão 50mm
In: TERREO
Type - PredefinedType: SINK
AltoQi_Builder - Indicação: 50mm; Posição: Direta
Identificação_Elemento - Aplicação: Aparelho sanitário; Descrição: Lava Louça - 50mm; Nome: 50mm; Classe: PVC Esgoto; Tipo: Pia de Cozinha Residencial com Sifão 50mm; Rede: Esgoto (Gordura)
Pset_SanitaryTerminalTypeCommon - Reference: Pia de Cozinha Residencial com Sifão 50mm
AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Sifão de copo p/ pia e lavatório - 1" - 2": 1; PVC Acessórios - Válvula p/ pia - 1": 1; PVC Esgoto - Joelho 90 - 50 mm: 2; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 60 cm

# IfcSanitaryTerminal: Pia de cozinha com joelho de 90º
In: TERREO
Type - PredefinedType: SINK
AltoQi_Builder - Vazão de projeto (l/s): 0.25; Indicação: PIA; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Pia de cozinha com joelho de 90º; Nome: 25 mm - 3/4" - Bancada; Classe: PVC rígido soldável; Tipo: Pia de cozinha com joelho de 90º; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Pia de cozinha com joelho de 90º
AltoQi_QiBuilder-Itens_Associados - Aparelho - Torneira de Pia de Cozinha - 25mm - 3/4": 1; PVC rígido soldável - Engate Flexível Reforçado de PVC - Engate Flexível Reforçado - 3/4" x 30 cm Aço Inox: 1; PVC soldável azul c/ bucha latão - Joelho 90º soldável com bucha de latão - 25 mm - 3/4": 1

# IfcSanitaryTerminal: Saídas livres
In: COBERTURA
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Vazão de projeto (l/s): 0; Indicação: Saída; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Saídas livres; Nome: 32 mm; Classe: PVC rígido soldável; Tipo: Saídas livres; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Saídas livres
AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento

# IfcSanitaryTerminal: Tanque de Lavar Roupas DN 40mm
In: TERREO
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Indicação: 40mm - QB; Posição: Direta
Identificação_Elemento - Aplicação: Aparelho sanitário; Descrição: Tanque de Lavar Roupas DN 40mm; Nome: 40mm; Classe: PVC Esgoto; Tipo: Tanque de Lavar Roupas DN 40mm; Rede: Esgoto
Pset_SanitaryTerminalTypeCommon - Reference: Tanque de Lavar Roupas DN 40mm
AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Sifão flexível c/ Adaptador - 1.1/2" - 1.1/2": 1; PVC Acessórios - Válvula p/ tanque - 1 1/2": 1; PVC Esgoto - Curva 90 curta - 40 mm: 1; PVC Esgoto - Joelho 90 c/anel p/ esgoto secundário - 40 mm - 1.1/2": 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 60 cm

# IfcSanitaryTerminal: Tanque de lavar com joelho de 90º
In: TERREO
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Vazão de projeto (l/s): 0.25; Indicação: TLR; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Tanque de lavar com joelho de 90º; Nome: 25 mm - 3/4" - Bancada; Classe: PVC rígido soldável; Tipo: Tanque de lavar com joelho de 90º; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Tanque de lavar com joelho de 90º
AltoQi_QiBuilder-Itens_Associados - Aparelho - Torneira de Tanque de Lavar - 25mmx 3/4": 1; PVC rígido soldável - Engate Flexível Reforçado de PVC - Engate Flexível Reforçado - 3/4" x 30 cm Aço Inox: 1; PVC soldável azul c/ bucha latão - Joelho 90º soldável com bucha de latão - 25 mm - 3/4": 1

# IfcSanitaryTerminal: Torneira de Jardim com joelho 90° (2)
In: TERREO
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Vazão de projeto (l/s): 0.2; Indicação: TJ; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Torneira de Jardim; Nome: 25 mm x 3/4"; Classe: PVC rígido soldável; Tipo: Torneira de Jardim com joelho 90°; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Torneira de Jardim com joelho 90°
AltoQi_QiBuilder-Itens_Associados - Aparelho - Torneira de Jardim - 25 mm x 3/4": 1; PVC soldável azul c/ bucha latão - Joelho 90º soldável com bucha de latão - 25 mm - 3/4": 1

# IfcSanitaryTerminal: Vaso Sanitário c/ J90º
In: TERREO
Type - PredefinedType: WCSEAT
AltoQi_Builder - Indicação: 100 mm; Posição: Direta
Identificação_Elemento - Aplicação: Aparelho sanitário; Descrição: Vaso Sanitário c/ J90º; Nome: 100 mm; Classe: PVC Esgoto; Tipo: Vaso Sanitário c/ J90º; Rede: Esgoto
Pset_SanitaryTerminalTypeCommon - Reference: Vaso Sanitário c/ J90º
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 90 - 100 mm: 1; PVC Esgoto - Vedação p/ saída de vaso sanitário - 100 mm: 1

# IfcSanitaryTerminal: Vaso sanitário com caixa acoplada
In: TERREO
Type - PredefinedType: WCSEAT
AltoQi_Builder - Vazão de projeto (l/s): 0.15; Indicação: VS; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Vaso sanitário com caixa acoplada; Nome: 3/4"; Classe: PVC rígido soldável; Tipo: Vaso sanitário com caixa acoplada; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Vaso sanitário com caixa acoplada
AltoQi_QiBuilder-Itens_Associados - Aparelho - Vaso Sanitário c/ cx. acoplada - 1/2": 1; PVC Acessórios - Engate flexível cobre cromado com canopla - 1/2 - 30cm: 1; PVC soldável azul c/ bucha latão - Joelho de redução 90º soldável com bucha de latão - 25 mm- 1/2": 1

# IfcStackTerminal: Terminal de ventilação- coluna (3)
In: COBERTURA
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Indicação: 50 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Terminal de ventilação- coluna; Nome: 50 mm; Classe: PVC Esgoto; Tipo: Terminal de ventilação- coluna; Rede: Ventilação
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Terminal de ventilação - 50 mm: 1
Name
CV-1
CV-2
CV-3

# IfcTank: Caixa d'água, RCi1
In: COBERTURA
Type - PredefinedType: STORAGE
AltoQi_Builder - Volume efetivo (l): 1000; Altura: 94.1 cm; Diâmetro: 144 cm; Indicação: 1000L; Posição: Direta; % do volume do reservatório: 100; Localização: Superior; Volume da RTI (m³): 0; Volume da edificação (m³/dia): 0.9; Volume útil estimado (m³): 0.9; Volume (m³): 1; Uso do reservatório: Reservatório da água
Identificação_Elemento - Aplicação: Reservatório cilíndrico; Descrição: Reservatório 1000L; Nome: 1000L; Classe: Reservatório cilíndrico; Tipo: Caixa d'água; Rede: Alimentação
Pset_TankTypeCommon - Reference: Caixa d'água; NominalCapacity: 1; NominalDepht: 94.1 cm; NominalLenghtOrDiameter: 144 cm
AltoQi_QiBuilder-Itens_Associados - Reservatório cilíndrico - Polietileno - 1000 L: 1

# IfcValve: Registro bruto gaveta ABNT c/PVC soldável (2)
In: COBERTURA
Type - PredefinedType: ISOLATING
AltoQi_Builder - Indicação: RG; Posição: Direta
Identificação_Elemento - Aplicação: Registro; Descrição: Registro bruto gaveta ABNT c/PVC soldável; Classe: PVC rígido soldável; Tipo: Registro bruto gaveta ABNT c/PVC soldável
Pset_ValveTypeCommon - Reference: Registro bruto gaveta ABNT c/PVC soldável
Name | Nome | Rede
 | 3/4" | Alimentação | AltoQi_QiBuilder-Itens_Associados - Metais - Registro de gaveta bruto ABNT - 3/4": 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 25 mm - 3/4": 2
 | 1" | Água fria | AltoQi_QiBuilder-Itens_Associados - Metais - Registro de gaveta bruto ABNT - 1": 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 32 mm - 1": 2

# IfcValve: Registro de gaveta c/canopla cromada c/PVC soldável (7)
In: TERREO
Type - PredefinedType: ISOLATING
AltoQi_Builder - Indicação: RG; Posição: Direta
Identificação_Elemento - Aplicação: Registro; Descrição: Registro de gaveta c/canopla cromada c/PVC soldável; Nome: 3/4"; Classe: PVC rígido soldável; Tipo: Registro de gaveta c/canopla cromada c/PVC soldável; Rede: Água fria
Pset_ValveTypeCommon - Reference: Registro de gaveta c/canopla cromada c/PVC soldável
AltoQi_QiBuilder-Itens_Associados - Metais - Registro de gaveta c/ canopla cromada - 3/4": 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 25 mm - 3/4": 2

# IfcValve: Registro de pressão c/ canopla cromada
In: TERREO
Type - PredefinedType: REGULATING
AltoQi_Builder - Indicação: RP; Posição: Direta
Identificação_Elemento - Aplicação: Registro; Descrição: Registro de pressão c/ canopla cromada; Nome: 3/4"; Classe: PVC rígido soldável; Tipo: Registro de pressão c/ canopla cromada; Rede: Água fria
Pset_ValveTypeCommon - Reference: Registro de pressão c/ canopla cromada
AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Registro de pressão c/ canopla cromada - 3/4": 1

# IfcWasteTerminal: Caixa Sifonada (2)
In: TERREO
Type - PredefinedType: FLOORWASTE
AltoQi_Builder - Comprimento: 15.5 cm; Diâmetro: 15 cm; Indicação: 150x150x50; Posição: Direta
Identificação_Elemento - Aplicação: Caixa sifonada; Descrição: Caixa Sifonada; Nome: 150x150x50; Classe: PVC Esgoto; Tipo: Caixa Sifonada; Rede: Esgoto
Pset_WasteTerminalTypeCommon - Reference: Caixa Sifonada
AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Caixa sifonada - 150x150x50: 1

# IfcWasteTerminal: Caixas Inspeção Esgoto Simples (3)
In: TERREO
Type - PredefinedType: FLOORWASTE
AltoQi_Builder - Comprimento: 60 cm; Largura: 60 cm; Indicação: CE- 40x 40cm; Posição: Direta
Identificação_Elemento - Aplicação: Caixa de alvenaria; Descrição: Caixas Inspeção Esgoto Simples; Nome: CE- 40x 40cm; Classe: Caixas de Passagem; Tipo: Caixas Inspeção Esgoto Simples; Rede: Esgoto
Pset_WasteTerminalTypeCommon - Reference: Caixas Inspeção Esgoto Simples
AltoQi_QiBuilder-Itens_Associados - Caixas de Passagem - Caixa de inspeção esgoto simples - CE- 40x40 cm: 1
